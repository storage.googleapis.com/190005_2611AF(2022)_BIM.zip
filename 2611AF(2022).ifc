Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-05-23T22:45:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 23 22:45:51 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{C908B833-C185-4821-996A-DD5D2AE37488}\ifc * Database version: 5507 * Database creation date: Mon May 23 22:45:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 23 22:45:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 23 22:45:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 2611AF(2022) Washbasin faucet, 2611AF(2022):2611AF(2022) Washbasin faucet:18506
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 185.942 mm; NominalHeight: 249.664 mm; NominalWidth: 97.4723 mm
Type - General - Author: BIMStone; BIMObjectName: 2611AF(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/05/2022
Type - Green Building Properties - EAN Number: 6414150099168; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/2611AF; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2611AF; Catalog Drawing URL: http://static.oras.com/catdrw/2611AF; Dimension Drawing URL: http://static.oras.com/dimdrw/2611AF; FDV Document URL: http://www.oras.com/datasheet/2611AF/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2611AF; Group: Washbasin faucet; Interactive AR View URL: https://static.oras.com/AR/2611AF; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2611AF; Model: 2611AF(2022) Washbasin faucet; Name_en: 2611AF(2022) Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2611AF(2022); Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/2611AF; Product URL: http://static.oras.com/2611AF; Technical DataSheet URL: http://www.oras.com/datasheet/2611AF/en; Type Name: 2611AF(2022) Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 152 mm; Spout Swivel Range: 120°; Spout Type: Swivel spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2611AF(2022); Features: Single-lever, side operated; Finish: Polished; Grade: n/a; Material: brassPlastic; ModelNumber: n/a; ModelReference: 2611AF(2022); Name: 2611AF(2022) Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x170x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.089982 m2; Volume: 0.00452967 m3
Identity Data - Mark: 7
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2611AF(2022): 2611AF(2022) Washbasin faucet; Family and Type: 2611AF(2022): 2611AF(2022) Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2611AF(2022): 2611AF(2022) Washbasin faucet; Type Id: 2611AF(2022): 2611AF(2022) Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
